# Keil uVision project nano.uvprojx, settings and files
target nano (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nano +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\USER;.\OS\src;.\OS\libcpu\arm\cortex-m4;.\OS\include\libc;.\OS\include;.\OS\bsp;.\CMSIS;.\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: main.c USART.c DAC.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group OS
    ./OS/src/: components.c device.c idle.c ipc.c irq.c clock.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
    ./OS/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ./OS/bsp/: board.c
