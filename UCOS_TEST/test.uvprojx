# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD
  c include: .\CMSIS;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\uCOS\CONFIG;.\uCOS\CORE;.\uCOS\PORT;.\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s SysTick.c
  group USER
    ./USER/: main.c USART.c
  group UCOS
    ./uCOS/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./uCOS/PORT/: os_cpu_c.c os_dbg.c os_cpu_a.asm
